Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-03-21T09:40:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Mar 21 09:40:17 2018* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{DFAEE7B4-44A3-49D6-82FB-71A735EC4FBA}\ifc* Database version: 5507* Database creation date: Wed Mar 21 09:40:15 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Mar 21 09:40:15 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Mar 21 09:40:15 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDoor: 5000x2200mm, NBS_ProfabAccessLtd_AcsPnls_Profab4000_QuintupleDoor:5000x2200mm:324243
In: Level 0
Type - ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_36_01 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_ProfabAccessLtd_AccessPanels_Profab4000-QuintupleDoor_5000x2200mm; ManufacturerName: Profab Access Ltd; ManufacturerURL: www.profabaccesspanels.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/pdid2y3t; NBSDescription: Access panels; NBSReference: 45-45-00/310; OmniClassCode: 22-08 31 16; OmniClassTitle: Access Panels and Frames; OmniClassVersion: Table 22 2012-05-16; ProductInformation: www.profabaccesspanels.co.uk/wp-content/uploads/Profab-Access-Ltd-Riser-Doors-B1.pdf; Revision: n/a; Uniclass2015Code: Pr_30_59_36_01; Uniclass2015Title: Access panels; Uniclass2015Version: Products v1.9; Version: 3
Type - NBS_Data - FireRatingOptions: 60 minutes, 120 minutes, 180 minutes, 240 minutes; Frame: 1.5 mm thick electro-galvanized carbon steel; FrameDepth: 59 mm; FrameOptions: Beaded frame (BF), Deep plaster frame (DPF), Picture frame (PF); LatchOrLockType: 3 Point Lock (3PL); LockingOptions: Three-point lock (3PL), Europrofile high security cylinder (3HS); LockNumber: 1; Operation: Concealed steel hinges outward opening; PanelFinishOptions: Powder coated primer, Semi-gloss; PanelIntegralFinish: Powder Coated; PanelType: 1.2 mm thick electro-galvanized carbon steel; Position: Wall mounted; Weight: 50 kg/m²
Type - Pset_DoorCommon - AcousticRating: 35 dB; DurabilityRating: n/a; FireExit: no; FireRating: n/a; GlazingAreaFraction: 0; HandicapAccessible: no; HasDrive: no; HygrothermalRating: n/a; Infiltration: 0; IsExternal: no; MechanicalLoadRating: n/a; Reference: n/a; SecurityRating: n/a; SelfClosing: no; SmokeStop: no; ThermalTransmittance: 0; WaterTightnessRating: n/a; WindLoadRating: n/a
Type - IFC - IfcExportAs: IfcDoorType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_36_01:Access panels; CodePerformance: n/a; Color: White; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Up to 240 minsUTES fire rated (3rd Party Certified), 36 dBrw acoustic rated, Airtight to Part L, Smoke sealed; Finish: n/a; Grade: n/a; Manufacturer: technical@profabaccess.com; Material: Carbon steel; ModelNumber: n/a; ModelReference: Profab 4000; Name: AccessPanels_Profab4000-QuintupleDoor_5000x2200mm_ProfabAccessLtd; NominalHeight: 2200 mm; NominalLength: 0 mm; NominalWidth: 5000 mm; ReplacementCost: n/a; Shape: n/a; Size: 5000 x 2200 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 1298.8 mm; OverallWidth: 5033.87 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
